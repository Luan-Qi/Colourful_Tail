# Keil uVision project Tail.uvprojx, settings and files
target Tail (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: AT32F421K8U7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LVGL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: .\BSP\Inc;.\Core\Inc;.\User\Inc;.\Middlewares\IIC;.\Middlewares\WS2812;.\Middlewares\PATTERN;.\Middlewares\BMI160
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./USER/: main.c
    ./User/: retarget.c
    ./User/Src/: at32f421_clock.c at32f421_int.c
  group lib
    ./User/Src/: delay.c usart.c timer.c led.c button.c adc.c
  group Cmsis
    ./Core/: system_at32f421.c startup_at32f421.s
  group Firmware
    ./BSP/Src/: at32f421_crm.c at32f421_misc.c at32f421_gpio.c at32f421_usart.c at32f421_i2c.c at32f421_dma.c at32f421_tmr.c at32f421_spi.c at32f421_adc.c
  group Middlewares
    ./Middlewares/IIC/: myiic.c
    ./Middlewares/WS2812/: ws2812.c
    ./Middlewares/PATTERN/: pattern.c
    ./Middlewares/BMI160/: BMI160.c
